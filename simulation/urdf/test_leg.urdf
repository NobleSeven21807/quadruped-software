Commit message: Attached legs to a body!

File: simulation/urdf/test_leg.urdf (robot description, URDF)
Before this commit: robot three_joint_leg, 4 links, 3 joints
Joints:
- joint hip_flexion: origin xyz=0.2 0 0 rpy=0 0 0 -> xyz=0.0 0 0 rpy=0 0 0
